# Keil uVision project TestBench_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: TestBench_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h Segment_0.c Segment_0.h Segment_0_aliases.h Common_0.c Common_0.h Common_0_aliases.h Segment_1.c Segment_1.h Segment_1_aliases.h Segment_2.c Segment_2.h Segment_2_aliases.h Segment_3.c Segment_3.h Segment_3_aliases.h Segment_4.c Segment_4.h Segment_4_aliases.h Segment_5.c Segment_5.h Segment_5_aliases.h Segment_6.c Segment_6.h Segment_6_aliases.h Segment_7.c Segment_7.h Segment_7_aliases.h Common_1.c Common_1.h Common_1_aliases.h Common_2.c Common_2.h Common_2_aliases.h Common_3.c Common_3.h Common_3_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h Button.c Button.h Button_aliases.h LED.c LED.h LED_RAM_1.c LED_RAM_1.h LED_RAM_2.c LED_RAM_2.h LED_PWM_Clock.c LED_PWM_Clock.h LED_Refresh_Clock.c LED_Refresh_Clock.h LED_COM_PWM.c LED_COM_PWM.h LED_COM_PWM_PM.c LED_Brightness_DMA_dma.c LED_Brightness_DMA_dma.h LED_Common_DMA_dma.c LED_Common_DMA_dma.h LED_Segment_DMA_dma.c LED_Segment_DMA_dma.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: TestBench_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
